# IAR project Project.ewp, settings and files
configuration LZY_WireTester (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F439xx; USE_STM32F429I_DISCO; USE_USB_HS
  ICCARM.CCIncludePath2: ..\..\Application\Core\Inc; ..\..\Application\Config; ..\..\Utilities\CPU; ..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\Drivers\BSP\STM32F429I-Discovery; ..\..\Drivers\BSP\Components\Common; ..\..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc; ..\..\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc; ..\..\Middlewares\ST\STemWin\inc; ..\..\Middlewares\Third_Party\FatFs\src; ..\..\Middlewares\Third_Party\FatFs\src\drivers; ..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\Middlewares\Third_Party\LwIP\src\include; ..\..\Middlewares\Third_Party\LwIP\src\include\ipv4; ..\..\Middlewares\Third_Party\LwIP\system; ..\..\Application\WireTester\Bsp; ..\..\Application\WireTester\Src; ..\..\Application\WireTester\User
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Application\Config
  OBJCOPY.OOCOutputFile: LZY_WireTester_V.hex
  ILINK.IlinkOutputFile: LZY_WireTester.out
  ILINK.IlinkIcfFile: stm32f429xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/Core
    ../../Application/Core/Src/: k_bsp.c k_calibration.c k_log.c k_mem.c k_module.c k_modules_res.c k_rtc.c k_storage.c main.c stm32f4xx_it.c
  group Application/EWARM
    ../../Application/startup_stm32f429xx/EWARM/: startup_stm32f429xx.s
  group Application/Modules/Benchmark
    ../../Application/Modules/benchmark/: benchmark_win.c
  group Application/Modules/FileBrowser
    ../../Application/Modules/filebrowser/: filebrowser_app.c filebrowser_win.c
  group Application/Modules/Game
    ../../Application/Modules/game/: game_win.c
  group Application/Modules/ImageBrowser
    ../../Application/Modules/imagebrowser/: imagebrowser_win.c
  group Application/Modules/System
    ../../Application/Modules/system/: system_win.c
  group Application/Modules/VideoPlayer
    ../../Application/Modules/videoplayer/: videoplayer_win.c
  group Application/Utilities
    ../../Utilities/CPU/: cpu_utils.c
  group Drivers/BSP/Components
    ../../Drivers/BSP/Components/ili6480/: ili6480.c
    ../../Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../../Drivers/BSP/Components/ts3510/: ts3510.c
  group Drivers/BSP/STM32F429I_Discovery
    ../../Drivers/BSP/STM32F429I-Discovery/: stm32f429i_discovery.c stm32f429i_discovery_eeprom.c stm32f429i_discovery_io.c stm32f429i_discovery_lcd.c stm32f429i_discovery_sdram.c stm32f429i_discovery_ts.c
  group Drivers/CMSIS
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_msp_template.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group Middlewares/FatFs/Core
    ../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Drivers
    ../../Middlewares/Third_Party/FatFs/src/drivers/: usbh_diskio.c
  group Middlewares/FatFs/Options
    ../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/FreeRTOS
    ../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/Portable
    ../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/STemWin/Config
    ../../Middlewares/ST/STemWin/Config/: GUIConf.c
    ../../Application/Config/: LCDConf_stm32f429i_disco_MB1075.c
  group Middlewares/STemWin/Library
    ../../Middlewares/ST/STemWin/Lib/: STemWin522_CM4_OS_IAR.a
  group Middlewares/STemWin/OS
    ../../Middlewares/ST/STemWin/OS/: GUI_X_FreeRTOS.c
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Middlewares/STM32_USBH_Library/Config
    ../../Application/Config/: usbh_conf.c
  group Middlewares/STM32_USBH_Library/Core
    ../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
